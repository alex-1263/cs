# Keil uVision project yuanma.uvproj, settings and files
target 目标 1 (MCS-51)
  device: Core8051 Microsemi
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(12000000)
  output: yuanma +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\温度，酒精lcd显示
  group 源组 1
    ./: STARTUP.A51 ym.c lcd1620.c usart.c
